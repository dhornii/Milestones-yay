Commit message: Update short_arm.urdf

File: Milestone6/Arm_Kinematics/urdf/short_arm.urdf (robot description, URDF)
Before this commit: robot shorter_cylinders_for_ik, 4 links, 3 joints
Joints:
- joint joint_baseTo1: axis -1 0 0 -> 0 -1 0
