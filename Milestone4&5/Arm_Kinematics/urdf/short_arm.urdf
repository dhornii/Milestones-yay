Commit message: Update short_arm.urdf

File: Milestone4&5/Arm_Kinematics/urdf/short_arm.urdf (robot description, URDF)
Before this commit: robot shorter_cylinders_for_ik, 4 links, 3 joints
Joints:
- joint joint_1To2: axis 0 1 0 -> 0 -1 0
- joint joint_baseTo1: axis 0 1 0 -> 0 -1 0
